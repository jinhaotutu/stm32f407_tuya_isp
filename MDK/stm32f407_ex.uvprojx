# Keil uVision project stm32f407_ex.uvprojx, settings and files
target stm32f4_project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_ex +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\fwlib\inc;..\sys;..\user;..\misis;..\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c stm32f4xx_it.c
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_flash.c stm32f4xx_rcc.c
  group misis
    ../misis/: system_stm32f4xx.c
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group sys
    ../sys/: sys_cfg.c
  group flash_stm32
    ../STMFLASH/: stmflash.c
